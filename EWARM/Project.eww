<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ProjectIS1300.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Test.ewp</path>
    </project>
    <batchBuild />
</workspace>
